# Repository bluecat523/Greenhouse-opener-Kicadfiles

File README.md:

# ハウス自動開閉機（Greenhouse Opener）制御基板製作用Kicadファイル

## 概要

Arduino を使った温室ハウスの自動開閉システムです。
現在開発中のオプション（WiFi通信、ハウス20棟まで対応可能、VPNサービスで外出先でも温度監視、開閉操作）
に対応しています。

## 構成
*Kicad-MainBoard*
  * メイン制御基板（モーター制御・センサー）
    
* Kicad-LCD*
  * 表示用LCD基板

## 特徴

* ローカルで完結（Wi-Fiなしでも動作可能）
* 農業現場で実運用中

## ファイルについて

* `.kicad_sch` → 回路図
* `.kicad_pcb` → 基板レイアウト
* `.kicad_pro` → プロジェクトファイル
* `Gerber.zip` → 基板発注用データ

KiCad バージョン 9.0 で作成しています。

## KiCad design Kicad-LCDBoard/Kicad/HC_R8_LCD.kicad_pcb

Parts:
C1, C2: 1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C3: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: Terminal; PinSocket_1x04_P2.54mm_Vertical
R1: 300; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: LCD-AQM0802A; LCD-AQM0802

Connections:
GND: C3.1, J1.1, U1.6 (G), U1.11 (K--)
unnamed: J1.3, U1.8 (SCL)
unnamed: J1.4, U1.7 (SDA)
unnamed: R1.1, U1.10 (A++)
unnamed: C2.1, U1.3 (CapIN)
unnamed: C2.2, U1.4 (CapIP)
unnamed: C1.1, U1.2 (Vout)
VCC: C1.2, C3.2, J1.2, R1.2, U1.5 (Vdd), U1.9 (RST)

Notes on the sheet:
SDA
SCL
Vcc

Board: 2 copper layers, 49.5 x 44.2 mm, 6 parts (4 on the bottom side), 8 nets.

## KiCad design Kicad-MainBoard/Kicad/HC_R8.kicad_pcb

Parts:
A1: Arduino_Nano
C1, C2: 0.22; C_Disc_D4.3mm_W1.9mm_P5.00mm
C3: 0.1m; C_Disc_D3.4mm_W2.1mm_P2.50mm
C4, C5: 10m; CP_Radial_D5.0mm_P2.50mm
C6: 0.33m; C_Disc_D3.4mm_W2.1mm_P2.50mm
D1, D2: D_Filled; D_A-405_P12.70mm_Horizontal
D3, D4: D; D_DO-34_SOD68_P10.16mm_Horizontal
D5, D6: D; Diode signal
J1, J2, J3, J4: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J5: Conn_01x03_Socket; PinSocket_1x03_P2.54mm_Vertical
J6: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
J9: Conn_01x06_Socket; PinSocket_1x06_P2.54mm_Vertical
Q1, Q2: SJ334; P-FET
R1, R2: 10; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R3, R4, R5, R6: 3.9k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R8: 510; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R9, R10: 0.47; R_Box_L13.0mm_W4.0mm_P9.00mm
R12: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R17, R18: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19, R20: 47ｋ; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
RY1, RY2, RY3, RY4: Hsinda943; relay-Hsinda943
U1, U2, U5, U6: TLP785; DIP-4_W7.62mm
U3: TBD62003APG; DIP-16_W7.62mm_Socket
U4: LM7805_TO220; TO-220-3_Vertical
ar1: GND; TH hole
arA0: M2u; TH hole
arA1: M2d; TH hole
arA2: M1u; TH hole
arA3: M1d; TH hole
arD3: Wind; TH hole
arD4: Dec; TH hole
arD7: Inc; TH hole
arD8: MEM; TH hole
arD11: M1 A/M; TH hole
arD12: M2 A/M; TH hole
arRST1: Res; TH hole

Connections:
+5V: A1.27 (+5V), C3.1, J5.2, J6.2, J9.6, R12.1, R19.1, R20.1, U4.3 (VO)
+12V: C6.1, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J3.2, RY1.5, RY2.5, RY3.5, RY4.5, U3.9 (COM), U4.1 (VI)
+24V: J4.1, Q1.3 (S), Q2.3 (S), R3.2, R4.2
A6: A1.25 (A6), C4.1, R19.2, U5.4
A7: A1.26 (A7), C5.1, R20.2, U6.4
DEC: A1.7 (D4), arD4.1
GND: A1.4 (GND), A1.29 (GND), C3.2, C4.2, C5.2, C6.2, J3.1, J5.1, J6.1, J9.3, U1.2, U2.2, U3.8 (GND), U4.2 (GND), U5.3, U6.3, ar1.1
GNDPWR: J4.2, R9.2, R10.2, U1.3, U2.3, U5.2, U6.2
M1 A/M: A1.14 (D11), arD11.1
M2 A/M: A1.15 (D12), arD12.1
unnamed: A1.19 (A0), arA0.1
unnamed: A1.20 (A1), arA1.1
unnamed: A1.21 (A2), arA2.1
unnamed: A1.22 (A3), arA3.1
unnamed: A1.2 (D0/RX), J9.5
unnamed: A1.1 (D1/TX), J9.4
unnamed: A1.5 (D2), J5.3, R12.2
unnamed: A1.8 (D5), J9.1, U3.3 (I3), U3.4 (I4)
unnamed: A1.9 (D6), J9.2, U3.1 (I1), U3.2 (I2)
unnamed: A1.10 (D7), arD7.1
unnamed: A1.11 (D8), arD8.1
unnamed: A1.12 (D9), R8.1
unnamed: A1.13 (D10), R7.1
unnamed: C1.1, R1.2
unnamed: C2.1, R2.2
unnamed: D1.2 (A), R9.1, R17.1, RY1.4, RY3.3
unnamed: D1.1 (K), Q1.2 (D), RY1.3, RY3.4
unnamed: D2.2 (A), R10.1, R18.1, RY2.4, RY4.3
unnamed: D2.1 (K), Q2.2 (D), RY2.3, RY4.4
unnamed: D3.2 (A), RY1.2, U3.13 (O4)
unnamed: D4.2 (A), RY2.2, U3.15 (O2)
unnamed: D5.2 (A), RY3.2, U3.14 (O3)
unnamed: D6.2 (A), RY4.2, U3.16 (O1)
unnamed: J1.1, R1.1, RY1.1
unnamed: C1.2, J1.2, RY3.1
unnamed: J2.1, R2.1, RY2.1
unnamed: C2.2, J2.2, RY4.1
unnamed: Q1.1 (G), R3.1, R5.2
unnamed: Q2.1 (G), R4.1, R6.2
unnamed: R5.1, U1.4
unnamed: R6.1, U2.4
unnamed: R7.2, U1.1
unnamed: R8.2, U2.1
unnamed: R17.2, U5.1
unnamed: R18.2, U6.1
unnamed: A1.3 (~RESET), arRST1.1
SCL: A1.24 (A5), J6.3
SDA: A1.23 (A4), J6.4
Wind: A1.6 (D3), arD3.1

Notes on the sheet:
M2up
M2 FET
M2dn
M1 FET
M1 A/M
M2 A/M
M1dr
INC
MEM
M1up
temp S
MEM
R8-4-17 12ｖ電源からのarduinoへのVin配線削除、5ｖ端子に3端子レギュレータ入力追加
DEC
R8-3-7 修正 オペアンプ回り削除 電流検出抵抗 0.22→0.47へ変更 C4，C5 追加 R17，R18 220Ωへ変更 R19，R20 47ｋへ変更
SDA
SCL
Wind
M2dr
M1dn

Board: 2 copper layers, 99.1 x 99.1 mm, 59 parts (4 on the bottom side), 49 nets.

## Commit log

2026-05-01 Initial upload (KiCad files)
2026-05-01 Add README for greenhouse opener project
    Added README.md for greenhouse opener project with details on features, structure, and file types.
2026-05-17 Added HC-R8-FrontpanelHoles
2026-05-17 Rename Kicad-LCD to Kicad-LCDBoard
